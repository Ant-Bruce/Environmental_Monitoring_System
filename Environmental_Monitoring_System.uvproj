# Keil uVision project Environmental_Monitoring_System.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Environmental_Monitoring_System +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Public;.\Tool
  group Main
    ./Main/: main.c
  group Public
    ./Public/: public.c uart.c
  group Tool
    ./Tool/: xpt2046.c lcd1602.c dh11.c mq2.c beep.c esp8266.c
